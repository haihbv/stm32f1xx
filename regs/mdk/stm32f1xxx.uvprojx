# Keil uVision project stm32f1xxx.uvprojx, settings and files
target dev (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_register
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\DRIVER\inc;..\DRIVER\src
  asm include: ..\driver\inc;..\driver\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../USER/: main.c main.h
  group src
    ../DRIVER/src/: rcc.c gpio.c afio.c exti.c tim.c adc.c systick.c uart.c
  group inc
    ../DRIVER/inc/: rcc.h gpio.h afio.h exti.h tim.h systick.h adc.h uart.h stm32_util.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
